# Keil uVision project stm32_rtxos.uvprojx, settings and files
target rtxos (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_rtxos
  BeforeMake: MCUTool.exe ap stm32f103apprtx 0x30000 0x800 0
  AfterMake: fromelf --bin !L --output ./stm32f103apprtx.bin
  AfterMake: MCUTool.exe ah ./stm32f103apprtx.bin  ./middleware/config/project_config.h
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_ASSERT,STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_STM3210B_EVAL
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.5.1\CMSIS\RTOS2\RTX\Include1;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.5.1\CMSIS\RTOS2\RTX\Source;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.5.1\CMSIS\Core\Include;.\RTE;.\RTE\Compiler;.\middleware;.\middleware\config;.\STM3210B_EVAL;.\Common;.\unpack;.\4g;.\rs485_broker;.\user;.\cjson_app;.\cjson;.\mqtt_app;.\mqtt;.\uart_dc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c ds18b20.c ta6932.c
  group middleware
    ./middleware/: st_printf.c clock_calendar.c st_backupreg.c st_rtc.c stm32f10x_ip_dbg.c stm32f10x_it.c st_gpio.c st_iwdg.c st_adc.c st_ext_spi_flash.c st_audio_product.c mod_date_time.c mod_time_list.c st_flash.c
  group readme
    ./readme/: readme.txt
  group Common
    ./Common/: stm32_eval_spi_flash.c
    ./STM3210B_EVAL/: stm32_eval.c
  group STM3210B_EVAL
    ./STM3210B_EVAL/: stm3210b_eval.c
  group res
    ./res/: audio_temp_high.c charge_part1.c charge.c audio_num1.c audio_device_open.c audio_charge_start.c audio_num6.c
  group unpack
    ./unpack/: unpack.c
  group 4g
    ./4g/: app4g.c ntp.c
  group app_rs485_broker
    ./rs485_broker/: app_rs485_broker.c
  group cjson
    ./cjson/: cJSON.c
  group cjson_app
    ./cjson_app/: cjson_middleware.c
  group mqtt
    ./mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqtt_app
    ./mqtt_app/: mqtt_app.c transport.c
  group uart_dc
    ./uart_dc/: dianchuan.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
